options:
  parameters:
    author: DISCRAFT
    category: '[GRC]'
    comment: 'Professional-style PlutoSDR digital voice transceiver: 16 kHz Opus CBR + rate-1/2 convolutional FEC + QPSK + RRC + synchronization. 433.92 MHz default. Use only within applicable RF rules/licensing.'
    description: High-quality low-latency digital voice transceiver for ADALM-Pluto with live RF spectrum, QPSK constellation, FLL, audio waveform and power monitoring.
    enable_cache: 'True'
    generate_options: qt_gui
    hier_block_src_path: '.'
    id: pluto_digital_voice_hd
    output_language: python
    redraw: 'True'
    thread_safe_setters: 'False'
    title: Pluto Digital Voice HD - Live Dashboard
  states: {}

blocks:
- name: samp_audio
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: QPSK samples per symbol
    value: '4'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    comment: 21.2 ksym/s, 424 symbols per 20 ms frame
    value: '21200'
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    comment: 4 samples/symbol × 21.2 ksym/s
    value: '84800'
  states: {}
- name: pluto_rate
  id: variable
  parameters:
    comment: 8× interpolation to a valid Pluto sample rate
    value: '678400'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    comment: Default is 433.92 MHz. Change only to a frequency you are authorized to use.
    gui_hint: 'dashboard@0: 0,0,1,2'
    label: TX frequency (Hz)
    rangeType: int
    start: '70000000'
    step: '1000'
    stop: '6000000000'
    value: '433920000'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    comment: Default is 433.92 MHz. Change only to a frequency you are authorized to use.
    gui_hint: 'dashboard@0: 1,0,1,2'
    label: RX frequency (Hz)
    rangeType: int
    start: '70000000'
    step: '1000'
    stop: '6000000000'
    value: '433920000'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    comment: Lower attenuation = higher RF output. Use only within legal power limits.
    gui_hint: 'dashboard@0: 2,0,1,2'
    label: TX attenuation (dB)
    start: '0'
    step: '0.25'
    stop: '60'
    value: '10'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: Start around 38 dB and increase only as needed.
    gui_hint: 'dashboard@0: 3,0,1,2'
    label: RX manual gain (dB)
    start: '0'
    step: '0.5'
    stop: '70'
    value: '38'
  states: {}
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    comment: Digital microphone gain before compression.
    gui_hint: 'dashboard@0: 4,0,1,2'
    label: Microphone gain
    start: '0.25'
    step: '0.05'
    stop: '3'
    value: '1'
  states: {}
- name: rx_volume
  id: variable_qtgui_range
  parameters:
    comment: Post-decoder speaker gain.
    gui_hint: 'dashboard@0: 5,0,1,2'
    label: RX volume
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {}
- name: ptt_enable
  id: variable_qtgui_chooser
  parameters:
    label: TX / PTT
    type: int
    num_opts: '2'
    options: '[0, 1]'
    value: '0'
    option0: '0'
    label0: RX / Standby
    option1: '1'
    label1: TX / PTT
    widget: radio_buttons
    orient: QtWidgets.QHBoxLayout
    gui_hint: 'dashboard@0: 6,0,1,2'
  states: {}
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    comment: Gray-coded QPSK constellation.
    const_points: '[0.70710678+0.70710678j, -0.70710678+0.70710678j, -0.70710678-0.70710678j, 0.70710678-0.70710678j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: audio_src
  id: audio_source
  parameters:
    comment: 16 kHz mono speech capture.
    samp_rate: samp_audio
  states: {}
- name: tx_dc
  id: dc_blocker_xx
  parameters:
    comment: Remove microphone DC bias.
    length: '64'
    long_form: 'True'
    type: ff
  states: {}
- name: dashboard
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Controls
    label1: RF Spectrum
    label2: Modem
    label3: Audio
    label4: System Notes
    num_tabs: '5'
  states: {}
- name: tx_hp
  id: high_pass_filter
  parameters:
    comment: Remove subsonic rumble.
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    samp_rate: samp_audio
    transition_width: '100'
    type: fir_filter_fff
    win: window.WIN_HAMMING
  states: {}
- name: tx_lp
  id: low_pass_filter
  parameters:
    comment: 'Speech bandwidth: ~100 Hz to 7 kHz.'
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_audio
    transition_width: '500'
    type: fir_filter_fff
    win: window.WIN_HAMMING
  states: {}
- name: tx_gain
  id: blocks_multiply_const_vxx
  parameters:
    comment: Microphone level trim.
    const: mic_gain
    type: float
    mode: scalar
  states: {}
- name: tx_limiter
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Low-latency soft limiter for speech."""
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="speech_soft_limiter",
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              self.drive = 1.8
              self.norm = np.tanh(self.drive)

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              y[:] = np.tanh(self.drive * x) / self.norm
              return len(y)
    _window_size: '0'
    comment: Prevents clipping and evens speech level.
  states: {}
- name: opus_enc
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import opuslib

      class blk(gr.basic_block):
          """CBR Opus 16 kHz mono, 20 ms frames, fixed 40-byte packets."""
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="opus_cbr_encoder_16k",
                  in_sig=[np.float32],
                  out_sig=[np.uint8])
              self.rate = 16000
              self.frame = 320
              self.packet_bytes = 40
              self.buf = np.empty(0, dtype=np.float32)
              self.enc = opuslib.Encoder(self.rate, 1, opuslib.APPLICATION_VOIP)
              self.enc.bitrate = 16000
              self.enc.vbr = False
              try:
                  self.enc.complexity = 10
              except Exception:
                  pass
              try:
                  self.enc.vbr_constraint = False
              except Exception:
                  pass

          def general_work(self, input_items, output_items):
              x = input_items[0]
              if len(x):
                  self.buf = np.concatenate((self.buf, x.astype(np.float32, copy=False)))
                  self.consume(0, len(x))

              out = output_items[0]
              nframes = min(len(self.buf) // self.frame, len(out) // self.packet_bytes)
              if nframes <= 0:
                  return 0

              produced = 0
              consumed = 0
              for _ in range(nframes):
                  pcm = np.clip(self.buf[consumed:consumed+self.frame], -1.0, 1.0)
                  pcm_i16 = (pcm * 32767.0).astype(np.int16)
                  packet = self.enc.encode(pcm_i16.tobytes(), self.frame)
                  if len(packet) != self.packet_bytes:
                      raise RuntimeError("Opus CBR packet size changed: expected 40 bytes, got %d" % len(packet))
                  out[produced:produced+self.packet_bytes] = np.frombuffer(packet, dtype=np.uint8)
                  produced += self.packet_bytes
                  consumed += self.frame

              self.buf = self.buf[consumed:]
              return produced
    _window_size: '0'
    comment: 'Opus: 16 kbps, 16 kHz mono, 20 ms CBR frames.'
  states: {}
- name: fec_tx
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import zlib
      from gnuradio import gr
      SYNC=0x1ACFFC1D
      G0=0o171; G1=0o133
      PRE_SYMS=np.array([0,1,2,3]*8,dtype=np.uint8)
      PRE_BITS=np.empty(64,dtype=np.uint8)
      PRE_BITS[0::2]=PRE_SYMS>>1; PRE_BITS[1::2]=PRE_SYMS&1
      SYNC_BITS=np.array([(SYNC>>i)&1 for i in range(31,-1,-1)],dtype=np.uint8)
      def bbits(b): return np.unpackbits(np.frombuffer(b,dtype=np.uint8),bitorder='big').astype(np.uint8)
      def conv(x):
          s=0; o=[]
          for bit in x:
              r=((s<<1)|int(bit))&0x7f; o.extend([(r&G0).bit_count()&1,(r&G1).bit_count()&1]); s=r&0x3f
          for _ in range(6):
              r=(s<<1)&0x7f; o.extend([(r&G0).bit_count()&1,(r&G1).bit_count()&1]); s=r&0x3f
          return np.asarray(o,dtype=np.uint8)
      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,name='voice_fec_framer',in_sig=[np.uint8],out_sig=[np.uint8]); self.buf=bytearray(); self.seq=0
          def general_work(self,input_items,output_items):
              x=input_items[0]
              if len(x): self.buf.extend(bytes(x.tolist())); self.consume(0,len(x))
              out=output_items[0]; frame_bits=848
              n=min(len(self.buf)//40,len(out)//frame_bits)
              if n<=0: return 0
              p=0
              for _ in range(n):
                  payload=bytes(self.buf[:40]); del self.buf[:40]
                  seq=(self.seq&0xffff).to_bytes(2,'big')
                  crc=zlib.crc32(seq+payload).to_bytes(4,'big')
                  c=conv(bbits(seq+payload+crc)); c=c.reshape(22,34).T.flatten()
                  out[p:p+848]=np.concatenate((PRE_BITS,SYNC_BITS,c,np.zeros(4,dtype=np.uint8)))
                  p+=848; self.seq=(self.seq+1)&0xffff
              return p
    _window_size: '0'
    comment: CRC32 + K=7 rate-1/2 convolutional FEC + 22x34 block interleaving. Self-contained for portability.
  states: {}
- name: unpack_bits_tx
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    comment: Pack 8 coded bits into each byte for QPSK symbol mapping.
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: qpsk_symbols_tx
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    comment: Split each packed byte into 2-bit QPSK symbol indices (0..3).
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: diff_enc_tx
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: qpsk_map_tx
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1+1j, -1+1j, -1-1j, 1-1j]'
  states: {}
- name: tx_rrc
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.25'
    comment: RRC pulse shaping; actual occupied waveform is ~24.5 kHz class.
    decim: '1'
    gain: '1'
    ntaps: '161'
    samp_rate: baseband_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: tx_ptt_gate
  id: blocks_multiply_const_vxx
  parameters:
    comment: Half-duplex PTT gate. Zero RF waveform when RX / Standby is selected.
    const: ptt_enable
    mode: scalar
    type: complex
  states: {}
- name: tx_to_pluto
  id: rational_resampler_xxx
  parameters:
    comment: '8x interpolation: 78.4 kS/s -> 627.2 kS/s.'
    decim: '1'
    fbw: '0.45'
    interp: '8'
    type: ccc
  states: {}
- name: pluto_tx
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq
    samplerate: pluto_rate
    type: fc32
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bbdc: 'True'
    bandwidth: '200000'
    buffer_size: '32768'
    comment: 200 kHz is Pluto hardware minimum; software channel filter follows.
    filter_source: '''Auto'''
    frequency: rx_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: pluto_rate
    type: fc32
  states: {}
- name: rx_decim
  id: rational_resampler_xxx
  parameters:
    comment: 627.2 kS/s -> 78.4 kS/s.
    decim: '8'
    fbw: '0.45'
    interp: '1'
    type: ccc
  states: {}
- name: rx_channel
  id: low_pass_filter
  parameters:
    comment: Software channel filter removes out-of-channel noise before synchronization.
    cutoff_freq: '12500'
    decim: '1'
    gain: '1'
    samp_rate: baseband_rate
    transition_width: '2500'
    type: fir_filter_ccf
    win: window.WIN_HAMMING
  states: {}
- name: rx_fll
  id: digital_fll_band_edge_cc
  parameters:
    comment: Coarse frequency recovery for independent Pluto oscillators.
    filter_size: '65'
    rolloff: '0.25'
    samps_per_sym: sps
    w: '0.02'
    type: cc
  states: {}
- name: rx_rrc
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.25'
    comment: Matched RRC filter before symbol timing recovery.
    decim: '1'
    gain: '1'
    ntaps: '161'
    samp_rate: baseband_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: rx_sym
  id: digital_symbol_sync_xx
  parameters:
    constellation: qpsk_const
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
    loop_bw: '0.03'
  states: {}
- name: rx_costas
  id: digital_costas_loop_cc
  parameters:
    comment: QPSK carrier recovery.
    order: '4'
    w: '0.01'
  states: {}
- name: rx_const_dec
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: rx_diff
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: rx_symbols_to_bits
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_interpolator):
          """Convert QPSK symbol index 0..3 into two MSB-first bit items."""
          def __init__(self):
              gr.sync_interpolator.__init__(self, name="qpsk_symbols_to_bits",
                                             interp=2, in_sig=[np.uint8], out_sig=[np.uint8])

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              n = len(x)
              y[0:2*n:2] = (x >> 1) & 1
              y[1:2*n:2] = x & 1
              return 2*n
    _window_size: '0'
    comment: Expand symbol indices back to individual FEC bits.
  states: {}
- name: fec_rx
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import zlib
      from gnuradio import gr
      SYNC=0x1ACFFC1D
      G0=0o171; G1=0o133
      PRE_SYMS=np.array([0,1,2,3]*8,dtype=np.uint8)
      PRE_BITS=np.empty(64,dtype=np.uint8)
      PRE_BITS[0::2]=PRE_SYMS>>1; PRE_BITS[1::2]=PRE_SYMS&1
      SYNC_BITS=np.array([(SYNC>>i)&1 for i in range(31,-1,-1)],dtype=np.uint8)
      PAT=np.concatenate((PRE_BITS,SYNC_BITS))
      NEXT=np.zeros((64,2),dtype=np.uint8); O0=np.zeros((64,2),dtype=np.uint8); O1=np.zeros((64,2),dtype=np.uint8)
      for s in range(64):
          for b in (0,1):
              r=((s<<1)|b)&0x7f; NEXT[s,b]=r&0x3f; O0[s,b]=(r&G0).bit_count()&1; O1[s,b]=(r&G1).bit_count()&1
      def vit(c):
          n=len(c)//2; INF=10**9; m=np.full(64,INF,dtype=np.int32); m[0]=0
          ps=np.zeros((n,64),dtype=np.int8); pb=np.zeros((n,64),dtype=np.int8)
          for t in range(n):
              r0=int(c[2*t]); r1=int(c[2*t+1]); nm=np.full(64,INF,dtype=np.int32)
              for s in range(64):
                  ms=int(m[s])
                  if ms>=INF: continue
                  for b in (0,1):
                      ns=int(NEXT[s,b]); v=ms+(int(O0[s,b])!=r0)+(int(O1[s,b])!=r1)
                      if v<int(nm[ns]): nm[ns]=v; ps[t,ns]=s; pb[t,ns]=b
              m=nm
          if m[0]>=INF: return None,INF
          out=np.zeros(n,dtype=np.uint8); s=0
          for t in range(n-1,-1,-1): out[t]=pb[t,s]; s=int(ps[t,s])
          return out,int(m[0])
      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,name='voice_fec_deframer',in_sig=[np.uint8],out_sig=[np.uint8]); self.buf=np.empty(0,dtype=np.uint8)
          def general_work(self,input_items,output_items):
              x=input_items[0]
              if len(x): self.buf=np.concatenate((self.buf,x.astype(np.uint8,copy=False))); self.consume(0,len(x))
              out=output_items[0]; made=0; total=848; plen=len(PAT)
              while len(self.buf)>=plen and made+42<=len(out):
                  found=-1
                  for i in range(len(self.buf)-plen+1):
                      if np.count_nonzero(self.buf[i:i+plen]!=PAT)<=5: found=i; break
                  if found<0: self.buf=self.buf[-(plen-1):]; break
                  if found>0: self.buf=self.buf[found:]
                  if len(self.buf)<total: break
                  frame=self.buf[:total]; coded=frame[plen:plen+748]
                  decbits,metric=vit(coded)
                  if decbits is not None and metric<=80:
                      body=np.packbits(decbits[:368],bitorder='big').tobytes(); seq=body[:2]; payload=body[2:42]; crc=body[42:46]
                      if len(body)>=46 and zlib.crc32(seq+payload).to_bytes(4,'big')==crc:
                          out[made:made+42]=np.frombuffer(seq+payload,dtype=np.uint8); made+=42; self.buf=self.buf[total:]; continue
                  self.buf=self.buf[1:]
              return made
    _window_size: '0'
    comment: Frame sync + Viterbi + CRC32. Emits 2-byte sequence + 40-byte Opus packet.
  states: {}
- name: opus_dec
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import opuslib

      class blk(gr.basic_block):
          """Sequence-aware Opus decoder with PLC for missing 20 ms frames."""
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="opus_cbr_decoder_16k",
                  in_sig=[np.uint8],
                  out_sig=[np.float32])
              self.rate = 16000
              self.frame = 320
              self.packet = 42
              self.buf = bytearray()
              self.have_seq = False
              self.expected = 0
              self.dec = opuslib.Decoder(self.rate, 1)
              self.audio_q = np.empty(0, dtype=np.float32)

          @staticmethod
          def dist(a,b):
              return (b-a) & 0xFFFF

          def push_packet(self, raw):
              seq = int.from_bytes(raw[:2], 'big')
              pkt = bytes(raw[2:])
              if not self.have_seq:
                  self.expected = seq
                  self.have_seq = True
              gap = self.dist(self.expected, seq)
              # Treat large backwards jumps as stale/out-of-order packets.
              if gap > 32768:
                  return
              for _ in range(gap):
                  plc = self.dec.decode(b'', self.frame)
                  a = np.frombuffer(plc, dtype=np.int16).astype(np.float32) / 32767.0
                  self.audio_q = np.concatenate((self.audio_q, a))
                  self.expected = (self.expected + 1) & 0xFFFF
              pcm = self.dec.decode(pkt, self.frame)
              a = np.frombuffer(pcm, dtype=np.int16).astype(np.float32) / 32767.0
              self.audio_q = np.concatenate((self.audio_q, a))
              self.expected = (seq + 1) & 0xFFFF

          def general_work(self, input_items, output_items):
              x = input_items[0]
              if len(x):
                  self.buf.extend(bytes(x.tolist()))
                  self.consume(0, len(x))
              out = output_items[0]
              while len(self.buf) >= self.packet:
                  raw = bytes(self.buf[:self.packet])
                  del self.buf[:self.packet]
                  try:
                      self.push_packet(raw)
                  except Exception:
                      # Drop malformed packet; next valid frame can resynchronize via sequence number.
                      continue
              n = min(len(out), len(self.audio_q))
              if n:
                  out[:n] = self.audio_q[:n]
                  self.audio_q = self.audio_q[n:]
              return n
    _window_size: '0'
    comment: 16 kHz mono Opus decode with packet-loss concealment.
  states: {}
- name: rx_volume_block
  id: blocks_multiply_const_vxx
  parameters:
    comment: Speaker volume.
    const: rx_volume
    type: float
    mode: scalar
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: samp_audio
  states: {}
- name: tx_fft
  id: qtgui_freq_sink_x
  parameters:
    alpha: '1.0'
    average: '0.2'
    bw: baseband_rate
    comment: TX baseband spectrum.
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'dashboard@1: 0,0,1,1'
    label: TX baseband spectrum
    name: TX baseband
    ref_level: '0'
    ref_scale: '1.0'
    showports: 'True'
    type: complex
  states: {}
- name: rx_fft
  id: qtgui_freq_sink_x
  parameters:
    alpha: '1.0'
    average: '0.2'
    bw: baseband_rate
    comment: RX filtered spectrum.
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'dashboard@1: 0,1,1,1'
    label: RX filtered spectrum
    name: RX filtered
    ref_level: '0'
    ref_scale: '1.0'
    showports: 'True'
    type: complex
  states: {}
- name: rx_const
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: QPSK constellation after timing/carrier recovery.
    grid: 'True'
    gui_hint: 'dashboard@2: 0,0,1,1'
    label: RX constellation
    name: QPSK
    size: '1024'
    trigger_mode: free
    type: complex
    x_axis: '0'
    x_max: '2'
    x_min: '-2'
    y_axis: '0'
    y_max: '2'
    y_min: '-2'
  states: {}
- name: note
  id: note
  parameters:
    content: |-
      FINAL DIGITAL VOICE

      16 kHz mono -> Opus 16 kbps CBR / 20 ms -> CRC32 -> K=7 rate-1/2 FEC -> 22x34 interleave -> preamble + sync -> differential Gray QPSK -> RRC alpha 0.25.

      424 QPSK symbols every 20 ms at 21.2 ksym/s. Baseband 84.8 kS/s. Pluto stream 678.4 kS/s. Approx. waveform bandwidth class 26.5 kHz. Pluto RF filter remains 200 kHz minimum.

      RX: software channel LPF -> FLL -> RRC/Gardner -> Costas -> constellation -> differential decode -> frame sync -> Viterbi -> CRC -> Opus PLC -> speaker.

      Install opuslib + system libopus. Start with cabled TX -> attenuator -> RX. Never connect TX directly to RX. Use only authorized frequencies, power and duty cycle.
  states: {}
- name: tx_const
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '"TX QPSK Constellation"'
    size: '2048'
    grid: 'True'
    ymin: '-1.5'
    ymax: '1.5'
    xmin: '-1.5'
    xmax: '1.5'
    gui_hint: 'dashboard@2: 1,0,1,1'
    tr_level: '0'
    label1: TX
    color1: blue
  states: {}
- name: tx_audio_time
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''TX Microphone'''
    size: '4000'
    srate: samp_audio
    grid: 'True'
    entags: 'False'
    gui_hint: 'dashboard@3: 0,0,1,1'
    tr_level: '0'
    label1: Mic
  states: {}
- name: rx_audio_time
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''RX Audio'''
    size: '4000'
    srate: samp_audio
    grid: 'True'
    entags: 'False'
    gui_hint: 'dashboard@3: 0,1,1,1'
    tr_level: '0'
    label1: RX
    color1: red
  states: {}
- name: fll_time
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''FLL Frequency Estimate'''
    size: '4000'
    srate: baseband_rate
    grid: 'True'
    ymin: '-0.2'
    ymax: '0.2'
    entags: 'False'
    gui_hint: 'dashboard@2: 0,1,1,1'
    tr_level: '0'
    label1: FLL
    color1: green
  states: {}
- name: tx_mag
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: tx_power_add
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '1e-12'
  states: {}
- name: tx_power_db
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: rx_mag
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_power_add
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '1e-12'
  states: {}
- name: rx_power_db
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: power_sink
  id: qtgui_number_sink
  parameters:
    name: '"Baseband Power"'
    type: float
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_VERT
    nconnections: '2'
    min: '-120'
    max: '5'
    update_time: '0.20'
    label1: TX
    unit1: dBFS
    label2: RX
    unit2: dBFS
    gui_hint: 'dashboard@1: 1,0,1,2'
  states: {}

connections:
- [audio_src, '0', tx_dc, '0']
- [tx_dc, '0', tx_hp, '0']
- [tx_hp, '0', tx_lp, '0']
- [tx_lp, '0', tx_gain, '0']
- [tx_gain, '0', tx_limiter, '0']
- [tx_limiter, '0', opus_enc, '0']
- [opus_enc, '0', fec_tx, '0']
- [fec_tx, '0', unpack_bits_tx, '0']
- [unpack_bits_tx, '0', qpsk_symbols_tx, '0']
- [qpsk_symbols_tx, '0', diff_enc_tx, '0']
- [diff_enc_tx, '0', qpsk_map_tx, '0']
- [qpsk_map_tx, '0', tx_rrc, '0']
- [tx_rrc, '0', tx_ptt_gate, '0']
- [tx_ptt_gate, '0', tx_to_pluto, '0']
- [tx_to_pluto, '0', pluto_tx, '0']
- [tx_ptt_gate, '0', tx_fft, '0']
- [pluto_rx, '0', rx_decim, '0']
- [rx_decim, '0', rx_channel, '0']
- [rx_channel, '0', rx_fft, '0']
- [rx_channel, '0', rx_fll, '0']
- [rx_fll, '0', rx_rrc, '0']
- [rx_rrc, '0', rx_sym, '0']
- [rx_sym, '0', rx_costas, '0']
- [rx_costas, '0', rx_const, '0']
- [rx_costas, '0', rx_const_dec, '0']
- [rx_const_dec, '0', rx_diff, '0']
- [rx_diff, '0', rx_symbols_to_bits, '0']
- [rx_symbols_to_bits, '0', fec_rx, '0']
- [fec_rx, '0', opus_dec, '0']
- [opus_dec, '0', rx_volume_block, '0']
- [rx_volume_block, '0', audio_sink, '0']
- [audio_src, '0', tx_audio_time, '0']
- [rx_fll, '1', fll_time, '0']
- [opus_dec, '0', rx_audio_time, '0']
- [qpsk_map_tx, '0', tx_const, '0']
- [tx_ptt_gate, '0', tx_mag, '0']
- [tx_mag, '0', tx_power_add, '0']
- [tx_power_add, '0', tx_power_db, '0']
- [tx_power_db, '0', power_sink, '0']
- [rx_channel, '0', rx_mag, '0']
- [rx_mag, '0', rx_power_add, '0']
- [rx_power_add, '0', rx_power_db, '0']
- [rx_power_db, '0', power_sink, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
