options:
  parameters:
    author: DISCRAFT
    catch_exceptions: 'True'
    category: '[GRC]'
    comment: 'Professional-style PlutoSDR digital voice transceiver: 16 kHz Opus CBR + rate-1/2 convolutional FEC + QPSK + RRC + synchronization. 433.92 MHz default. Use only within applicable RF rules/licensing.'
    description: High-quality low-latency digital voice transceiver for ADALM-Pluto with live RF spectrum, QPSK constellation, FLL, audio waveform and power monitoring.
    enable_cache: 'True'
    gen_cmake: 'On'
    generate_options: qt_gui
    hier_block_src_path: .
    id: pluto_digital_voice_hd
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    redraw: 'True'
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: prompt
    sizing_mode: fixed
    thread_safe_setters: 'False'
    title: Pluto Digital Voice HD - Live Dashboard
    window_size: (1600, 1000)
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 0
    - 0
    description: ''
    domain: std
    pythread: false
    realtime_scheduling: '1'
    run: true
    run_on: ''
    translation_language: none
    thread_safe_setters: false
    title: Not titled yet
blocks:
- name: samp_audio
  id: variable
  parameters:
    comment: ''
    value: '16000'
  states:
    coordinate:
    - 80
    - 80
    rotation: 0
    state: enabled
- name: sps
  id: variable
  parameters:
    comment: QPSK samples per symbol
    value: '4'
  states:
    coordinate:
    - 80
    - 140
    rotation: 0
    state: enabled
- name: sym_rate
  id: variable
  parameters:
    comment: 21.2 ksym/s, 424 symbols per 20 ms frame
    value: '21200'
  states:
    coordinate:
    - 80
    - 320
    rotation: 0
    state: enabled
- name: baseband_rate
  id: variable
  parameters:
    comment: "4 samples/symbol \xD7 21.2 ksym/s"
    value: '84800'
  states:
    coordinate:
    - 80
    - 200
    rotation: 0
    state: enabled
- name: pluto_rate
  id: variable
  parameters:
    comment: "8\xD7 interpolation to a valid Pluto sample rate"
    value: '678400'
  states:
    coordinate:
    - 80
    - 260
    rotation: 0
    state: enabled
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    comment: Default is 433.92 MHz. Change only to a frequency you are authorized to use.
    gui_hint: 'dashboard@0: 0,0,1,2'
    label: TX frequency (Hz)
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: int
    start: '70000000'
    step: '1000'
    stop: '6000000000'
    value: '433920000'
    widget: counter_slider
  states:
    coordinate:
    - 80
    - 330
    rotation: 0
    state: enabled
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    comment: Default is 433.92 MHz. Change only to a frequency you are authorized to use.
    gui_hint: 'dashboard@0: 1,0,1,2'
    label: RX frequency (Hz)
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: int
    start: '70000000'
    step: '1000'
    stop: '6000000000'
    value: '433920000'
    widget: counter_slider
  states:
    coordinate:
    - 80
    - 400
    rotation: 0
    state: enabled
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    comment: Lower attenuation = higher RF output. Use only within legal power limits.
    gui_hint: 'dashboard@0: 2,0,1,2'
    label: TX attenuation (dB)
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: float
    start: '0'
    step: '0.25'
    stop: '60'
    value: '10'
    widget: counter_slider
  states:
    coordinate:
    - 80
    - 470
    rotation: 0
    state: enabled
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: Start around 38 dB and increase only as needed.
    gui_hint: 'dashboard@0: 3,0,1,2'
    label: RX manual gain (dB)
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: float
    start: '0'
    step: '0.5'
    stop: '70'
    value: '38'
    widget: counter_slider
  states:
    coordinate:
    - 80
    - 540
    rotation: 0
    state: enabled
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    comment: Digital microphone gain before compression.
    gui_hint: 'dashboard@0: 4,0,1,2'
    label: Microphone gain
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: float
    start: '0.25'
    step: '0.05'
    stop: '3'
    value: '1'
    widget: counter_slider
  states:
    coordinate:
    - 80
    - 610
    rotation: 0
    state: enabled
- name: rx_volume
  id: variable_qtgui_range
  parameters:
    comment: Post-decoder speaker gain.
    gui_hint: 'dashboard@0: 5,0,1,2'
    label: RX volume
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: float
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
    widget: counter_slider
  states:
    coordinate:
    - 80
    - 680
    rotation: 0
    state: enabled
- name: ptt_enable
  id: variable_qtgui_chooser
  parameters:
    label: TX / PTT
    type: int
    num_opts: '2'
    options: '[0, 1]'
    labels: '[]'
    value: '0'
    option0: '0'
    label0: RX / Standby
    option1: '1'
    label1: TX / PTT
    option2: '2'
    label2: ''
    option3: '3'
    label3: ''
    option4: '4'
    label4: ''
    widget: radio_buttons
    orient: QtWidgets.QHBoxLayout
    gui_hint: 'dashboard@0: 6,0,1,2'
  states:
    coordinate:
    - 80
    - 750
    rotation: 0
    state: enabled
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    comment: Gray-coded QPSK constellation.
    const_points: '[0.70710678+0.70710678j, -0.70710678+0.70710678j, -0.70710678-0.70710678j, 0.70710678-0.70710678j]'
    imag_sect: '2'
    precision: '8'
    real_sect: '2'
    rot_sym: '4'
    soft_dec_lut: None
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states:
    coordinate:
    - 360
    - 80
    rotation: 0
    state: enabled
- name: audio_src
  id: audio_source
  parameters:
    comment: 16 kHz mono speech capture.
    device_name: ''
    num_outputs: '1'
    ok_to_block: 'True'
    samp_rate: samp_audio
  states:
    coordinate:
    - 40
    - 860
    rotation: 0
    state: enabled
- name: tx_dc
  id: dc_blocker_xx
  parameters:
    comment: Remove microphone DC bias.
    length: '64'
    long_form: 'True'
    type: ff
  states:
    coordinate:
    - 180
    - 860
    rotation: 0
    state: enabled
- name: dashboard
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Controls
    label1: RF Spectrum
    label2: Modem
    label3: Audio
    label4: System Notes
    label5: Tab 5
    label6: Tab 6
    label7: Tab 7
    label8: Tab 8
    label9: Tab 9
    label10: Tab 10
    label11: Tab 11
    label12: Tab 12
    label13: Tab 13
    label14: Tab 14
    label15: Tab 15
    label16: Tab 16
    label17: Tab 17
    label18: Tab 18
    label19: Tab 19
    num_tabs: '5'
  states:
    coordinate:
    - 20
    - 60
    rotation: 0
    state: enabled
- name: tx_hp
  id: high_pass_filter
  parameters:
    beta: '6.76'
    comment: Remove subsonic rumble.
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    interp: '1'
    samp_rate: samp_audio
    width: '100'
    type: fir_filter_fff
    win: window.WIN_HAMMING
  states:
    coordinate:
    - 330
    - 860
    rotation: 0
    state: enabled
- name: tx_lp
  id: low_pass_filter
  parameters:
    beta: '6.76'
    comment: 'Speech bandwidth: ~100 Hz to 7 kHz.'
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    interp: '1'
    samp_rate: samp_audio
    width: '500'
    type: fir_filter_fff
    win: window.WIN_HAMMING
  states:
    coordinate:
    - 500
    - 860
    rotation: 0
    state: enabled
- name: tx_gain
  id: blocks_multiply_const_vxx
  parameters:
    comment: Microphone level trim.
    const: mic_gain
    type: float
    vlen: '1'
    mode: scalar
  states:
    coordinate:
    - 680
    - 860
    rotation: 0
    state: enabled
- name: tx_limiter
  id: epy_block
  parameters:
    _io_cache: ''
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Low-latency soft limiter for speech.\"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n\
      \            name=\"speech_soft_limiter\",\n            in_sig=[np.float32],\n            out_sig=[np.float32])\n        self.drive = 1.8\n        self.norm = np.tanh(self.drive)\n\n    def work(self,\
      \ input_items, output_items):\n        x = input_items[0]\n        y = output_items[0]\n        y[:] = np.tanh(self.drive * x) / self.norm\n        return len(y)\n"
    _window_size: '0'
    comment: Prevents clipping and evens speech level.
    affinity: ''
    alias: ''
    maxoutbuf: '0'
    minoutbuf: '0'
  states:
    coordinate:
    - 850
    - 860
    rotation: 0
    state: enabled
- name: opus_enc
  id: epy_block
  parameters:
    _io_cache: ''
    _source_code: "import ctypes\nimport ctypes.util\nimport numpy as np\nfrom gnuradio import gr\n\nOPUS_APPLICATION_VOIP = 2048\nOPUS_SET_BITRATE_REQUEST = 4002\nOPUS_SET_VBR_REQUEST = 4006\nOPUS_SET_COMPLEXITY_REQUEST = 4010\n\nclass blk(gr.basic_block):\n    \\\"\\\"\\\"Opus 16 kHz mono, 16 kbps CBR, 20 ms frames via libopus C API.\\\"\\\"\\\"\n    def __init__(self):\n        gr.basic_block.__init__(self, name=\\\"opus_cbr_encoder_16k\\\", in_sig=[np.float32], out_sig=[np.uint8])\n        libname = ctypes.util.find_library(\\\"opus\\\") or \\\"libopus.so.0\\\"\n        self.lib = ctypes.CDLL(libname)\n        self.lib.opus_encoder_create.argtypes = [ctypes.c_int, ctypes.c_int, ctypes.c_int, ctypes.POINTER(ctypes.c_int)]\n        self.lib.opus_encoder_create.restype = ctypes.c_void_p\n        self.lib.opus_encoder_ctl.restype = ctypes.c_int\n        self.lib.opus_encode.argtypes = [ctypes.c_void_p, ctypes.POINTER(ctypes.c_int16), ctypes.c_int, ctypes.POINTER(ctypes.c_ubyte), ctypes.c_int]\n        self.lib.opus_encode.restype = ctypes.c_int\n        self.lib.opus_encoder_destroy.argtypes = [ctypes.c_void_p]\n        err = ctypes.c_int()\n        self.enc = self.lib.opus_encoder_create(16000, 1, OPUS_APPLICATION_VOIP, ctypes.byref(err))\n        if not self.enc or err.value != 0:\n            raise RuntimeError(\\\"libopus encoder creation failed (error %d)\\\" % err.value)\n        for req, val in ((OPUS_SET_BITRATE_REQUEST,16000),(OPUS_SET_VBR_REQUEST,0),(OPUS_SET_COMPLEXITY_REQUEST,10)):\n            if self.lib.opus_encoder_ctl(self.enc, ctypes.c_int(req), ctypes.c_int(val)) != 0:\n                raise RuntimeError(\\\"libopus encoder control request %d failed\\\" % req)\n        self.frame=320; self.packet_bytes=40; self.buf=np.empty(0,dtype=np.float32)\n    def stop(self):\n        if getattr(self,\\\"enc\\\",None): self.lib.opus_encoder_destroy(self.enc); self.enc=None\n        return super().stop()\n    def general_work(self,input_items,output_items):\n        x=input_items[0]\n        if len(x): self.buf=np.concatenate((self.buf,x.astype(np.float32,copy=False))); self.consume(0,len(x))\n        out=output_items[0]; n=min(len(self.buf)//self.frame,len(out)//self.packet_bytes)\n        if n<=0: return 0\n        p=0\n        for i in range(n):\n            pcm=np.clip(self.buf[i*320:(i+1)*320],-1.0,1.0)\n            pcm16=(pcm*32767.0).astype(np.int16)\n            obuf=(ctypes.c_ubyte*4000)()\n            nb=self.lib.opus_encode(self.enc,pcm16.ctypes.data_as(ctypes.POINTER(ctypes.c_int16)),320,obuf,4000)\n            if nb != 40: raise RuntimeError(\\\"libopus returned %d bytes; expected 40 for 16 kbps CBR/20 ms\\\" % nb)\n            out[p:p+40]=np.frombuffer(bytes(obuf[:40]),dtype=np.uint8); p+=40\n        self.buf=self.buf[n*320:]\n        return p\n"
    _window_size: '0'
    comment: '16 kHz mono Opus 16 kbps CBR, 20 ms using system libopus; no opuslib Python package required.'
    affinity: ''
    alias: ''
    maxoutbuf: '0'
    minoutbuf: '0'
  states:
    coordinate:
    - 1030
    - 860
    rotation: 0
    state: enabled
- name: fec_tx
  id: epy_block
  parameters:
    _io_cache: ''
    _source_code: "import numpy as np\nimport zlib\nfrom gnuradio import gr\nSYNC=0x1ACFFC1D\nG0=0o171; G1=0o133\nPRE_SYMS=np.array([0,1,2,3]*8,dtype=np.uint8)\nPRE_BITS=np.empty(64,dtype=np.uint8)\nPRE_BITS[0::2]=PRE_SYMS>>1;\
      \ PRE_BITS[1::2]=PRE_SYMS&1\nSYNC_BITS=np.array([(SYNC>>i)&1 for i in range(31,-1,-1)],dtype=np.uint8)\ndef bbits(b): return np.unpackbits(np.frombuffer(b,dtype=np.uint8),bitorder='big').astype(np.uint8)\n\
      def conv(x):\n    s=0; o=[]\n    for bit in x:\n        r=((s<<1)|int(bit))&0x7f; o.extend([(r&G0).bit_count()&1,(r&G1).bit_count()&1]); s=r&0x3f\n    for _ in range(6):\n        r=(s<<1)&0x7f; o.extend([(r&G0).bit_count()&1,(r&G1).bit_count()&1]);\
      \ s=r&0x3f\n    return np.asarray(o,dtype=np.uint8)\nclass blk(gr.basic_block):\n    def __init__(self):\n        gr.basic_block.__init__(self,name='voice_fec_framer',in_sig=[np.uint8],out_sig=[np.uint8]);\
      \ self.buf=bytearray(); self.seq=0\n    def general_work(self,input_items,output_items):\n        x=input_items[0]\n        if len(x): self.buf.extend(bytes(x.tolist())); self.consume(0,len(x))\n\
      \        out=output_items[0]; frame_bits=848\n        n=min(len(self.buf)//40,len(out)//frame_bits)\n        if n<=0: return 0\n        p=0\n        for _ in range(n):\n            payload=bytes(self.buf[:40]);\
      \ del self.buf[:40]\n            seq=(self.seq&0xffff).to_bytes(2,'big')\n            crc=zlib.crc32(seq+payload).to_bytes(4,'big')\n            c=conv(bbits(seq+payload+crc)); c=c.reshape(22,34).T.flatten()\n\
      \            out[p:p+848]=np.concatenate((PRE_BITS,SYNC_BITS,c,np.zeros(4,dtype=np.uint8)))\n            p+=848; self.seq=(self.seq+1)&0xffff\n        return p\n"
    _window_size: '0'
    comment: CRC32 + K=7 rate-1/2 convolutional FEC + 22x34 block interleaving. Self-contained for portability.
    affinity: ''
    alias: ''
    maxoutbuf: '0'
    minoutbuf: '0'
  states:
    coordinate:
    - 1210
    - 860
    rotation: 0
    state: enabled
- name: unpack_bits_tx
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    comment: Pack 8 coded bits into each byte for QPSK symbol mapping.
    endianness: gr.GR_MSB_FIRST
    num_ports: '1'
    type: byte
  states:
    coordinate:
    - 1390
    - 860
    rotation: 0
    state: enabled
- name: qpsk_symbols_tx
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    comment: Split each packed byte into 2-bit QPSK symbol indices (0..3).
    endianness: gr.GR_MSB_FIRST
    num_ports: '1'
    type: byte
  states:
    coordinate:
    - 1480
    - 860
    rotation: 0
    state: enabled
- name: diff_enc_tx
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states:
    coordinate:
    - 1650
    - 860
    rotation: 0
    state: enabled
- name: qpsk_map_tx
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    num_ports: '1'
    out_type: complex
    symbol_table: '[1+1j, -1+1j, -1-1j, 1-1j]'
  states:
    coordinate:
    - 1810
    - 860
    rotation: 0
    state: enabled
- name: tx_rrc
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.25'
    comment: Interpolating RRC: 21.2 ksym/s -> 84.8 kS/s.
    gain: '1'
    interp: '4'
    ntaps: '161'
    samp_rate: baseband_rate
    sym_rate: sym_rate
    type: interp_fir_filter_ccf
  states:
    coordinate:
    - 1820
    - 860
    rotation: 0
    state: enabled
- name: tx_ptt_gate
  id: blocks_multiply_const_vxx
  parameters:
    comment: Half-duplex PTT gate. Zero RF waveform when RX / Standby is selected.
    const: ptt_enable
    mode: scalar
    type: complex
    vlen: '1'
  states:
    coordinate:
    - 1960
    - 860
    rotation: 0
    state: enabled
- name: tx_to_pluto
  id: rational_resampler_xxx
  parameters:
    comment: '8x interpolation: 84.8 kS/s -> 678.4 kS/s.'
    decim: '1'
    fbw: '0.45'
    interp: '8'
    taps: '[]'
    type: ccc
  states:
    coordinate:
    - 2110
    - 860
    rotation: 0
    state: enabled
- name: pluto_tx
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    fpass: '0'
    filter: ''
    filter_source: '''Auto'''
    fstop: '0'
    frequency: tx_freq
    len_tag_key: ''
    samplerate: pluto_rate
    type: fc32
    uri: ''
  states:
    coordinate:
    - 2280
    - 860
    rotation: 0
    state: enabled
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bbdc: 'True'
    bandwidth: '200000'
    buffer_size: '32768'
    comment: 200 kHz is Pluto hardware minimum; software channel filter follows.
    fpass: '0'
    filter: ''
    filter_source: '''Auto'''
    fstop: '0'
    frequency: rx_freq
    gain1: '''manual'''
    len_tag_key: packet_len
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: pluto_rate
    type: fc32
    uri: ''
  states:
    coordinate:
    - 80
    - 1110
    rotation: 0
    state: enabled
- name: rx_decim
  id: rational_resampler_xxx
  parameters:
    comment: 684.8 kS/s -> 84.8 kS/s.
    decim: '8'
    fbw: '0.45'
    interp: '1'
    taps: '[]'
    type: ccc
  states:
    coordinate:
    - 270
    - 1110
    rotation: 0
    state: enabled
- name: rx_channel
  id: low_pass_filter
  parameters:
    beta: '6.76'
    comment: Software channel filter removes out-of-channel noise before synchronization.
    cutoff_freq: '12500'
    decim: '1'
    gain: '1'
    interp: '1'
    samp_rate: baseband_rate
    width: '2500'
    type: fir_filter_ccf
    win: window.WIN_HAMMING
  states:
    coordinate:
    - 450
    - 1110
    rotation: 0
    state: enabled
- name: rx_fll
  id: digital_fll_band_edge_cc
  parameters:
    comment: Coarse frequency recovery for independent Pluto oscillators.
    filter_size: '65'
    rolloff: '0.25'
    samps_per_sym: sps
    w: '0.02'
    type: cc
  states:
    coordinate:
    - 650
    - 1110
    rotation: 0
    state: enabled
- name: rx_rrc
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.25'
    comment: Matched RRC filter before symbol timing recovery.
    decim: '1'
    gain: '1'
    interp: '1'
    ntaps: '161'
    samp_rate: baseband_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states:
    coordinate:
    - 850
    - 1110
    rotation: 0
    state: enabled
- name: rx_sym
  id: digital_symbol_sync_xx
  parameters:
    constellation: qpsk_const
    damping: '1.0'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: '[]'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
    loop_bw: '0.03'
  states:
    coordinate:
    - 1050
    - 1110
    rotation: 0
    state: enabled
- name: rx_costas
  id: digital_costas_loop_cc
  parameters:
    comment: QPSK carrier recovery.
    order: '4'
    use_snr: 'False'
    w: '0.01'
  states:
    coordinate:
    - 1240
    - 1110
    rotation: 0
    state: enabled
- name: rx_const_dec
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states:
    coordinate:
    - 1420
    - 1110
    rotation: 0
    state: enabled
- name: rx_diff
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states:
    coordinate:
    - 1580
    - 1110
    rotation: 0
    state: enabled
- name: rx_symbols_to_bits
  id: epy_block
  parameters:
    _io_cache: ''
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_interpolator):\n    \"\"\"Convert QPSK symbol index 0..3 into two MSB-first bit items.\"\"\"\n    def __init__(self):\n\
      \        gr.sync_interpolator.__init__(self, name=\"qpsk_symbols_to_bits\",\n                                       interp=2, in_sig=[np.uint8], out_sig=[np.uint8])\n\n    def work(self, input_items,\
      \ output_items):\n        x = input_items[0]\n        y = output_items[0]\n        n = len(x)\n        y[0:2*n:2] = (x >> 1) & 1\n        y[1:2*n:2] = x & 1\n        return 2*n\n"
    _window_size: '0'
    comment: Expand symbol indices back to individual FEC bits.
    affinity: ''
    alias: ''
    maxoutbuf: '0'
    minoutbuf: '0'
  states:
    coordinate:
    - 1740
    - 1110
    rotation: 0
    state: enabled
- name: fec_rx
  id: epy_block
  parameters:
    _io_cache: ''
    _source_code: "import numpy as np\nimport zlib\nfrom gnuradio import gr\nSYNC=0x1ACFFC1D\nG0=0o171; G1=0o133\nPRE_SYMS=np.array([0,1,2,3]*8,dtype=np.uint8)\nPRE_BITS=np.empty(64,dtype=np.uint8)\nPRE_BITS[0::2]=PRE_SYMS>>1;\
      \ PRE_BITS[1::2]=PRE_SYMS&1\nSYNC_BITS=np.array([(SYNC>>i)&1 for i in range(31,-1,-1)],dtype=np.uint8)\nPAT=np.concatenate((PRE_BITS,SYNC_BITS))\nNEXT=np.zeros((64,2),dtype=np.uint8); O0=np.zeros((64,2),dtype=np.uint8);\
      \ O1=np.zeros((64,2),dtype=np.uint8)\nfor s in range(64):\n    for b in (0,1):\n        r=((s<<1)|b)&0x7f; NEXT[s,b]=r&0x3f; O0[s,b]=(r&G0).bit_count()&1; O1[s,b]=(r&G1).bit_count()&1\ndef vit(c):\n\
      \    n=len(c)//2; INF=10**9; m=np.full(64,INF,dtype=np.int32); m[0]=0\n    ps=np.zeros((n,64),dtype=np.int8); pb=np.zeros((n,64),dtype=np.int8)\n    for t in range(n):\n        r0=int(c[2*t]); r1=int(c[2*t+1]);\
      \ nm=np.full(64,INF,dtype=np.int32)\n        for s in range(64):\n            ms=int(m[s])\n            if ms>=INF: continue\n            for b in (0,1):\n                ns=int(NEXT[s,b]); v=ms+(int(O0[s,b])!=r0)+(int(O1[s,b])!=r1)\n\
      \                if v<int(nm[ns]): nm[ns]=v; ps[t,ns]=s; pb[t,ns]=b\n        m=nm\n    if m[0]>=INF: return None,INF\n    out=np.zeros(n,dtype=np.uint8); s=0\n    for t in range(n-1,-1,-1): out[t]=pb[t,s];\
      \ s=int(ps[t,s])\n    return out,int(m[0])\nclass blk(gr.basic_block):\n    def __init__(self):\n        gr.basic_block.__init__(self,name='voice_fec_deframer',in_sig=[np.uint8],out_sig=[np.uint8]);\
      \ self.buf=np.empty(0,dtype=np.uint8)\n    def general_work(self,input_items,output_items):\n        x=input_items[0]\n        if len(x): self.buf=np.concatenate((self.buf,x.astype(np.uint8,copy=False)));\
      \ self.consume(0,len(x))\n        out=output_items[0]; made=0; total=848; plen=len(PAT)\n        while len(self.buf)>=plen and made+42<=len(out):\n            found=-1\n            for i in range(len(self.buf)-plen+1):\n\
      \                if np.count_nonzero(self.buf[i:i+plen]!=PAT)<=5: found=i; break\n            if found<0: self.buf=self.buf[-(plen-1):]; break\n            if found>0: self.buf=self.buf[found:]\n\
      \            if len(self.buf)<total: break\n            frame=self.buf[:total]; coded=frame[plen:plen+748]\n            decbits,metric=vit(coded)\n            if decbits is not None and metric<=80:\n\
      \                body=np.packbits(decbits[:368],bitorder='big').tobytes(); seq=body[:2]; payload=body[2:42]; crc=body[42:46]\n                if len(body)>=46 and zlib.crc32(seq+payload).to_bytes(4,'big')==crc:\n\
      \                    out[made:made+42]=np.frombuffer(seq+payload,dtype=np.uint8); made+=42; self.buf=self.buf[total:]; continue\n            self.buf=self.buf[1:]\n        return made\n"
    _window_size: '0'
    comment: Frame sync + Viterbi + CRC32. Emits 2-byte sequence + 40-byte Opus packet.
    affinity: ''
    alias: ''
    maxoutbuf: '0'
    minoutbuf: '0'
  states:
    coordinate:
    - 1900
    - 1110
    rotation: 0
    state: enabled
- name: opus_dec
  id: epy_block
  parameters:
    _io_cache: ''
    _source_code: "import ctypes\nimport ctypes.util\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    \\\"\\\"\\\"Opus 16 kHz mono decoder with packet-loss concealment via libopus C API.\\\"\\\"\\\"\n    def __init__(self):\n        gr.basic_block.__init__(self,name=\\\"opus_decoder_16k\\\",in_sig=[np.uint8],out_sig=[np.float32])\n        libname=ctypes.util.find_library(\\\"opus\\\") or \\\"libopus.so.0\\\"\n        self.lib=ctypes.CDLL(libname)\n        self.lib.opus_decoder_create.argtypes=[ctypes.c_int,ctypes.c_int,ctypes.POINTER(ctypes.c_int)]\n        self.lib.opus_decoder_create.restype=ctypes.c_void_p\n        self.lib.opus_decoder_decode.argtypes=[ctypes.c_void_p,ctypes.POINTER(ctypes.c_ubyte),ctypes.c_int,ctypes.POINTER(ctypes.c_int16),ctypes.c_int,ctypes.c_int]\n        self.lib.opus_decoder_decode.restype=ctypes.c_int\n        self.lib.opus_decoder_destroy.argtypes=[ctypes.c_void_p]\n        err=ctypes.c_int()\n        self.dec=self.lib.opus_decoder_create(16000,1,ctypes.byref(err))\n        if not self.dec or err.value!=0: raise RuntimeError(\\\"libopus decoder creation failed (error %d)\\\" % err.value)\n        self.frame=320; self.packet=42; self.buf=bytearray(); self.audio_q=np.empty(0,dtype=np.float32); self.expected=None\n    def stop(self):\n        if getattr(self,\\\"dec\\\",None): self.lib.opus_decoder_destroy(self.dec); self.dec=None\n        return super().stop()\n    def decode_one(self,pkt):\n        pcm=(ctypes.c_int16*320)()\n        if pkt is None:\n            n=self.lib.opus_decoder_decode(self.dec,None,0,pcm,320,0)\n        else:\n            raw=(ctypes.c_ubyte*len(pkt)).from_buffer_copy(pkt)\n            n=self.lib.opus_decoder_decode(self.dec,raw,len(pkt),pcm,320,0)\n        if n<0: raise RuntimeError(\\\"libopus decode failed (%d)\\\" % n)\n        return np.ctypeslib.as_array(pcm)[:n].astype(np.float32)/32767.0\n    def push(self,raw):\n        seq=int.from_bytes(raw[:2],\\\"big\\\"); pkt=bytes(raw[2:])\n        if self.expected is None: self.expected=seq\n        gap=(seq-self.expected)&0xffff\n        if gap>32768: return\n        for _ in range(gap):\n            self.audio_q=np.concatenate((self.audio_q,self.decode_one(None))); self.expected=(self.expected+1)&0xffff\n        self.audio_q=np.concatenate((self.audio_q,self.decode_one(pkt))); self.expected=(seq+1)&0xffff\n    def general_work(self,input_items,output_items):\n        x=input_items[0]\n        if len(x): self.buf.extend(bytes(x.tolist())); self.consume(0,len(x))\n        while len(self.buf)>=self.packet:\n            raw=bytes(self.buf[:self.packet]); del self.buf[:self.packet]\n            try: self.push(raw)\n            except Exception: pass\n        out=output_items[0]; n=min(len(out),len(self.audio_q))\n        if n: out[:n]=self.audio_q[:n]; self.audio_q=self.audio_q[n:]\n        return n\n"
    _window_size: '0'
    comment: '16 kHz mono Opus decoder with PLC; uses system libopus directly.'
    affinity: ''
    alias: ''
    maxoutbuf: '0'
    minoutbuf: '0'
  states:
    coordinate:
    - 2070
    - 1110
    rotation: 0
    state: enabled
- name: rx_volume_block
  id: blocks_multiply_const_vxx
  parameters:
    comment: Speaker volume.
    const: rx_volume
    type: float
    vlen: '1'
    mode: scalar
  states:
    coordinate:
    - 2240
    - 1110
    rotation: 0
    state: enabled
- name: audio_sink
  id: audio_sink
  parameters:
    device_name: ''
    num_inputs: '1'
    ok_to_block: 'True'
    samp_rate: samp_audio
  states:
    coordinate:
    - 2400
    - 1110
    rotation: 0
    state: enabled
- name: tx_fft
  id: qtgui_freq_sink_x
  parameters:
    alias: ''
    alpha: '1.0'
    autoscale: 'False'
    average: '0.2'
    axislabels: 'True'
    bw: baseband_rate
    comment: TX baseband spectrum.
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'True'
    grid: 'True'
    gui_hint: 'dashboard@1: 0,0,1,1'
    label: TX baseband spectrum
    name: TX baseband
    nconnections: '1'
    ref_level: '0'
    ref_scale: '1.0'
    showports: 'True'
    type: complex
    update_time: '0.10'
    wintype: window.WIN_BLACKMAN_hARRIS
  states:
    coordinate:
    - 1930
    - 700
    rotation: 0
    state: enabled
- name: rx_fft
  id: qtgui_freq_sink_x
  parameters:
    alias: ''
    alpha: '1.0'
    autoscale: 'False'
    average: '0.2'
    axislabels: 'True'
    bw: baseband_rate
    comment: RX filtered spectrum.
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'True'
    grid: 'True'
    gui_hint: 'dashboard@1: 0,1,1,1'
    label: RX filtered spectrum
    name: RX filtered
    nconnections: '1'
    ref_level: '0'
    ref_scale: '1.0'
    showports: 'True'
    type: complex
    update_time: '0.10'
    wintype: window.WIN_BLACKMAN_hARRIS
  states:
    coordinate:
    - 470
    - 980
    rotation: 0
    state: enabled
- name: rx_const
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '"QPSK constellation"'
    size: '2048'
    grid: 'True'
    autoscale: 'True'
    ymin: '-1.5'
    ymax: '1.5'
    xmin: '-1.5'
    xmax: '1.5'
    nconnections: '1'
    update_time: '0.10'
    gui_hint: 'dashboard@2: 0,0,1,1'
    tr_mode: qtgui.TRIG_MODE_FREE
    tr_slope: qtgui.TRIG_SLOPE_POS
    tr_level: '0.0'
    tr_chan: '0'
    tr_tag: '""'
    legend: 'True'
    axislabels: 'True'
    label1: 'RX symbols'
    width1: '1'
    color1: '"blue"'
    style1: '0'
    marker1: '0'
    alpha1: '1.0'
  states:
    coordinate:
    - 1120
    - 980
    rotation: 0
    state: enabled
- name: note
  id: note
  parameters:
    content: 'FINAL DIGITAL VOICE


      16 kHz mono -> Opus 16 kbps CBR / 20 ms -> CRC32 -> K=7 rate-1/2 FEC -> 22x34 interleave -> preamble + sync -> differential Gray QPSK -> RRC alpha 0.25.


      424 QPSK symbols every 20 ms at 21.2 ksym/s. Baseband 84.8 kS/s. Pluto stream 684.8 kS/s. Approx. waveform bandwidth class 26.5 kHz. Pluto RF filter remains 200 kHz minimum.


      RX: software channel LPF -> FLL -> RRC/Gardner -> Costas -> constellation -> differential decode -> frame sync -> Viterbi -> CRC -> Opus PLC -> speaker.


      Install opuslib + system libopus. Start with cabled TX -> attenuator -> RX. Never connect TX directly to RX. Use only authorized frequencies, power and duty cycle.'
  states:
    coordinate:
    - 80
    - 750
    rotation: 0
    state: enabled
- name: tx_const
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '"TX QPSK Constellation"'
    size: '2048'
    grid: 'True'
    autoscale: 'False'
    ymin: '-1.5'
    ymax: '1.5'
    xmin: '-1.5'
    xmax: '1.5'
    nconnections: '1'
    update_time: '0.10'
    gui_hint: 'dashboard@2: 1,0,1,1'
    tr_mode: qtgui.TRIG_MODE_FREE
    tr_slope: qtgui.TRIG_SLOPE_POS
    tr_level: '0'
    tr_chan: '0'
    tr_tag: '""'
    axislabels: 'True'
    legend: 'True'
    label1: TX
    width1: '1'
    color1: blue
    alpha1: '1.0'
    style1: '0'
    marker1: '0'
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    label7: ''
    label8: ''
    label9: ''
    label10: ''
    width2: '1'
    width3: '1'
    width4: '1'
    width5: '1'
    width6: '1'
    width7: '1'
    width8: '1'
    width9: '1'
    width10: '1'
    color2: red
    color3: red
    color4: red
    color5: red
    color6: red
    color7: red
    color8: red
    color9: red
    color10: red
    alpha2: '1'
    alpha3: '1'
    alpha4: '1'
    alpha5: '1'
    alpha6: '1'
    alpha7: '1'
    alpha8: '1'
    alpha9: '1'
    alpha10: '1'
  states:
    coordinate:
    - 1640
    - 980
    rotation: 0
    state: enabled
- name: tx_audio_time
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''TX Microphone'''
    ylabel: Amplitude