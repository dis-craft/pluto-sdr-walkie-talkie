options:
  parameters:
    author: DISCRAFT
    category: DISCRAFT Pluto SDR
    comment: FINAL canonical PlutoSDR digital voice flowgraph. This file is intentionally self-identifying as DISCRAFT FINAL and contains no samp_rate=32000 variable.
    description: High-quality low-latency digital voice transceiver for ADALM-Pluto with live RF spectrum, QPSK constellation, FLL, audio waveform and power monitoring.
    generate_options: qt_gui
    hier_block_src_path: '.'
    id: pluto_discraft_digital_voice_final
    output_language: python
    title: DISCRAFT Pluto Digital Voice - FINAL
  states: {}

blocks:
- name: antenna_freq
  id: variable
  parameters:
    comment: Center of TX/RX operating frequencies.
    value: (tx_freq + rx_freq) / 2.0
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    comment: 4 samples/symbol × 21.2 ksym/s
    value: '84800'
  states: {}
- name: c0
  id: variable
  parameters:
    comment: Speed of light (m/s).
    value: '299792458.0'
  states: {}
- name: half_wave_cm
  id: variable
  parameters:
    comment: Approximate free-space half-wave dipole total length in cm.
    value: 100.0 * c0 / antenna_freq / 2.0
  states: {}
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    comment: Digital microphone gain before compression.
    label: Microphone gain
    start: '0.25'
    step: '0.05'
    stop: '3'
    value: '1'
  states: {}
- name: pluto_rate
  id: variable
  parameters:
    comment: 8× interpolation to a valid Pluto sample rate
    value: '1696000'
  states: {}
- name: ptt_enable
  id: variable_qtgui_chooser
  parameters:
    label: TX / PTT
    label0: RX / Standby
    label1: TX / PTT
    num_opts: '2'
    option0: '0'
    option1: '1'
    options: '[0, 1]'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    comment: Gray-coded QPSK constellation.
    const_points: '[0.70710678+0.70710678j, -0.70710678+0.70710678j, -0.70710678-0.70710678j, 0.70710678-0.70710678j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: quarter_wave_cm
  id: variable
  parameters:
    comment: Approximate free-space quarter-wave length in cm.
    value: 100.0 * c0 / antenna_freq / 4.0
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    comment: Default is 433.92 MHz. Change only to a frequency you are authorized to use.
    label: RX frequency (Hz)
    rangeType: int
    start: '325000000'
    step: '1000'
    stop: '3800000000'
    value: '433920000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: Start around 38 dB and increase only as needed.
    label: RX manual gain (dB)
    start: '0'
    step: '0.5'
    stop: '70'
    value: '38'
  states: {}
- name: rx_volume
  id: variable_qtgui_range
  parameters:
    comment: Post-decoder speaker gain.
    label: RX volume
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {}
- name: samp_audio
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: sim_audio_amp
  id: variable_qtgui_range
  parameters:
    comment: Simulation tone amplitude.
    label: Simulation Audio Level
    min_len: '220'
    start: '0.05'
    step: '0.01'
    stop: '0.70'
    value: '0.25'
  states: {}
- name: sim_audio_freq
  id: variable_qtgui_range
  parameters:
    comment: Tone frequency for no-hardware simulation.
    label: Simulation Audio Tone (Hz)
    min_len: '220'
    start: '200'
    step: '10'
    stop: '3000'
    value: '800'
  states: {}
- name: sim_freq_offset
  id: variable
  parameters:
    comment: Normalized channel frequency offset.
    value: sim_freq_offset_hz/pluto_rate
  states: {}
- name: sim_freq_offset_hz
  id: variable_qtgui_range
  parameters:
    comment: Carrier offset injected by the simulated channel.
    label: Simulation Frequency Offset (Hz)
    min_len: '220'
    start: '-2500'
    step: '10'
    stop: '2500'
    value: '0'
  states: {}
- name: sim_noise
  id: variable_qtgui_range
  parameters:
    comment: AWGN noise voltage in simulation.
    label: Simulation Noise
    min_len: '220'
    start: '0'
    step: '0.001'
    stop: '0.10'
    value: '0.0'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: QPSK samples per symbol
    value: '4'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    comment: 21.2 ksym/s, 424 symbols per 20 ms frame
    value: '21200'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    comment: Lower attenuation = higher RF output. Use only within legal power limits.
    label: TX attenuation (dB)
    start: '0'
    step: '0.25'
    stop: '60'
    value: '10'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    comment: Default is 433.92 MHz. Change only to a frequency you are authorized to use.
    label: TX frequency (Hz)
    rangeType: int
    start: '325000000'
    step: '1000'
    stop: '3800000000'
    value: '433920000'
  states: {}
- name: tx_monitor_gain
  id: variable_qtgui_range
  parameters:
    comment: 'Optional sidetone: monitor your live transmit voice before Opus/FEC. Use headphones to avoid acoustic feedback.'
    label: TX monitor (sidetone)
    min_len: '220'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: audio_mix
  id: blocks_add_xx
  parameters:
    comment: Mix optional TX sidetone with decoded RX audio.
    type: float
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: samp_audio
  states: {}
- name: audio_src
  id: audio_source
  parameters:
    comment: LIVE 16 kHz mono microphone input.
    samp_rate: samp_audio
  states: {}
- name: fec_rx
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import zlib
      from gnuradio import gr
      SYNC=0x1ACFFC1D
      G0=0o171; G1=0o133
      PRE_SYMS=np.array([0,1,2,3]*8,dtype=np.uint8)
      PRE_BITS=np.empty(64,dtype=np.uint8)
      PRE_BITS[0::2]=PRE_SYMS>>1; PRE_BITS[1::2]=PRE_SYMS&1
      SYNC_BITS=np.array([(SYNC>>i)&1 for i in range(31,-1,-1)],dtype=np.uint8)
      PAT=np.concatenate((PRE_BITS,SYNC_BITS))
      NEXT=np.zeros((64,2),dtype=np.uint8); O0=np.zeros((64,2),dtype=np.uint8); O1=np.zeros((64,2),dtype=np.uint8)
      for s in range(64):
          for b in (0,1):
              r=((s<<1)|b)&0x7f; NEXT[s,b]=r&0x3f; O0[s,b]=(r&G0).bit_count()&1; O1[s,b]=(r&G1).bit_count()&1
      def vit(c):
          n=len(c)//2; INF=10**9; m=np.full(64,INF,dtype=np.int32); m[0]=0
          ps=np.zeros((n,64),dtype=np.int8); pb=np.zeros((n,64),dtype=np.int8)
          for t in range(n):
              r0=int(c[2*t]); r1=int(c[2*t+1]); nm=np.full(64,INF,dtype=np.int32)
              for s in range(64):
                  ms=int(m[s])
                  if ms>=INF: continue
                  for b in (0,1):
                      ns=int(NEXT[s,b]); v=ms+(int(O0[s,b])!=r0)+(int(O1[s,b])!=r1)
                      if v<int(nm[ns]): nm[ns]=v; ps[t,ns]=s; pb[t,ns]=b
              m=nm
          if m[0]>=INF: return None,INF
          out=np.zeros(n,dtype=np.uint8); s=0
          for t in range(n-1,-1,-1): out[t]=pb[t,s]; s=int(ps[t,s])
          return out,int(m[0])
      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,name='voice_fec_deframer',in_sig=[np.uint8],out_sig=[np.uint8]); self.buf=np.empty(0,dtype=np.uint8)
          def general_work(self,input_items,output_items):
              x=input_items[0]
              if len(x): self.buf=np.concatenate((self.buf,x.astype(np.uint8,copy=False))); self.consume(0,len(x))
              out=output_items[0]; made=0; total=848; plen=len(PAT)
              while len(self.buf)>=plen and made+42<=len(out):
                  found=-1
                  for i in range(len(self.buf)-plen+1):
                      if np.count_nonzero(self.buf[i:i+plen]!=PAT)<=5: found=i; break
                  if found<0: self.buf=self.buf[-(plen-1):]; break
                  if found>0: self.buf=self.buf[found:]
                  if len(self.buf)<total: break
                  frame=self.buf[:total]; coded=frame[plen:plen+748].reshape(34,22).T.flatten()
                  decbits,metric=vit(coded)
                  if decbits is not None and metric<=80:
                      body=np.packbits(decbits[:368],bitorder='big').tobytes(); seq=body[:2]; payload=body[2:42]; crc=body[42:46]
                      if len(body)>=46 and zlib.crc32(seq+payload).to_bytes(4,'big')==crc:
                          out[made:made+42]=np.frombuffer(seq+payload,dtype=np.uint8); made+=42; self.buf=self.buf[total:]; continue
                  self.buf=self.buf[1:]
              return made
    comment: Frame sync + Viterbi + CRC32. Emits 2-byte sequence + 40-byte Opus packet.
  states: {}
- name: fec_tx
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import zlib
      from gnuradio import gr
      SYNC=0x1ACFFC1D
      G0=0o171; G1=0o133
      PRE_SYMS=np.array([0,1,2,3]*8,dtype=np.uint8)
      PRE_BITS=np.empty(64,dtype=np.uint8)
      PRE_BITS[0::2]=PRE_SYMS>>1; PRE_BITS[1::2]=PRE_SYMS&1
      SYNC_BITS=np.array([(SYNC>>i)&1 for i in range(31,-1,-1)],dtype=np.uint8)
      def bbits(b): return np.unpackbits(np.frombuffer(b,dtype=np.uint8),bitorder='big').astype(np.uint8)
      def conv(x):
          s=0; o=[]
          for bit in x:
              r=((s<<1)|int(bit))&0x7f; o.extend([(r&G0).bit_count()&1,(r&G1).bit_count()&1]); s=r&0x3f
          for _ in range(6):
              r=(s<<1)&0x7f; o.extend([(r&G0).bit_count()&1,(r&G1).bit_count()&1]); s=r&0x3f
          return np.asarray(o,dtype=np.uint8)
      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,name='voice_fec_framer',in_sig=[np.uint8],out_sig=[np.uint8]); self.buf=bytearray(); self.seq=0
          def general_work(self,input_items,output_items):
              x=input_items[0]
              if len(x): self.buf.extend(bytes(x.tolist())); self.consume(0,len(x))
              out=output_items[0]; frame_bits=848
              n=min(len(self.buf)//40,len(out)//frame_bits)
              if n<=0: return 0
              p=0
              for _ in range(n):
                  payload=bytes(self.buf[:40]); del self.buf[:40]
                  seq=(self.seq&0xffff).to_bytes(2,'big')
                  crc=zlib.crc32(seq+payload).to_bytes(4,'big')
                  c=conv(bbits(seq+payload+crc)); c=c.reshape(22,34).T.flatten()
                  out[p:p+848]=np.concatenate((PRE_BITS,SYNC_BITS,c,np.zeros(4,dtype=np.uint8)))
                  p+=848; self.seq=(self.seq+1)&0xffff
              return p
    comment: CRC32 + K=7 rate-1/2 convolutional FEC + 22x34 block interleaving. Self-contained for portability.
  states: {}
- name: final_marker
  id: note
  parameters: {}
  states: {}
- name: fll_time
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    entags: 'False'
    grid: 'True'
    label1: FLL
    name: '"FLL estimate"'
    size: '2000'
    srate: baseband_rate
    tr_level: '0'
    type: float
    ylabel: Frequency estimate
    ymax: '0.2'
    ymin: '-0.2'
    yunit: normalized
  states: {}
- name: note
  id: note
  parameters: {}
  states: {}
- name: note2
  id: note
  parameters: {}
  states: {}
- name: opus_dec
  id: epy_block
  parameters:
    _source_code: |-
      import ctypes
      import ctypes.util
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='opus_decoder_16k',
                  in_sig=[np.uint8],
                  out_sig=[np.float32]
              )
              libname = ctypes.util.find_library('opus') or 'libopus.so.0'
              self.lib = ctypes.CDLL(libname)
              self.lib.opus_decoder_create.argtypes = [
                  ctypes.c_int, ctypes.c_int,
                  ctypes.POINTER(ctypes.c_int)
              ]
              self.lib.opus_decoder_create.restype = ctypes.c_void_p
              self.lib.opus_decode.argtypes = [
                  ctypes.c_void_p,
                  ctypes.POINTER(ctypes.c_ubyte),
                  ctypes.c_int,
                  ctypes.POINTER(ctypes.c_int16),
                  ctypes.c_int,
                  ctypes.c_int
              ]
              self.lib.opus_decode.restype = ctypes.c_int
              self.lib.opus_decoder_destroy.argtypes = [ctypes.c_void_p]
              err = ctypes.c_int()
              self.dec = self.lib.opus_decoder_create(
                  16000, 1, ctypes.byref(err)
              )
              if not self.dec or err.value != 0:
                  raise RuntimeError(
                      'libopus decoder creation failed (error %d)' % err.value
                  )
              self.frame = 320
              self.packet = 42
              self.buf = bytearray()
              self.audio_q = np.empty(0, dtype=np.float32)
              self.expected = None

          def stop(self):
              if getattr(self, 'dec', None):
                  self.lib.opus_decoder_destroy(self.dec)
                  self.dec = None
              return super().stop()

          def decode_one(self, pkt):
              pcm = (ctypes.c_int16 * self.frame)()
              if pkt is None:
                  n = self.lib.opus_decode(
                      self.dec, None, 0, pcm, self.frame, 0
                  )
              else:
                  raw = (ctypes.c_ubyte * len(pkt)).from_buffer_copy(pkt)
                  n = self.lib.opus_decode(
                      self.dec, raw, len(pkt), pcm, self.frame, 0
                  )
              if n < 0:
                  raise RuntimeError('libopus decode failed (%d)' % n)
              return (
                  np.ctypeslib.as_array(pcm)[:n]
                  .astype(np.float32) / 32767.0
              )

          def push(self, raw):
              seq = int.from_bytes(raw[:2], 'big')
              pkt = bytes(raw[2:])
              if self.expected is None:
                  self.expected = seq
              gap = (seq - self.expected) & 0xffff
              if gap > 32768:
                  return
              for _ in range(gap):
                  self.audio_q = np.concatenate(
                      (self.audio_q, self.decode_one(None))
                  )
                  self.expected = (self.expected + 1) & 0xffff
              self.audio_q = np.concatenate(
                  (self.audio_q, self.decode_one(pkt))
              )
              self.expected = (seq + 1) & 0xffff

          def general_work(self, input_items, output_items):
              x = input_items[0]
              if len(x):
                  self.buf.extend(bytes(x.tolist()))
                  self.consume(0, len(x))
              while len(self.buf) >= self.packet:
                  raw = bytes(self.buf[:self.packet])
                  del self.buf[:self.packet]
                  try:
                      self.push(raw)
                  except Exception:
                      pass
              out = output_items[0]
              n = min(len(out), len(self.audio_q))
              if n:
                  out[:n] = self.audio_q[:n]
                  self.audio_q = self.audio_q[n:]
              return n
    comment: 16 kHz mono Opus decoder with packet-loss concealment using system libopus.
  states: {}
- name: opus_enc
  id: epy_block
  parameters:
    _source_code: |-
      import ctypes
      import ctypes.util
      import numpy as np
      from gnuradio import gr

      OPUS_APPLICATION_VOIP = 2048
      OPUS_SET_BITRATE_REQUEST = 4002
      OPUS_SET_VBR_REQUEST = 4006
      OPUS_SET_COMPLEXITY_REQUEST = 4010

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='opus_cbr_encoder_16k',
                  in_sig=[np.float32],
                  out_sig=[np.uint8]
              )
              libname = ctypes.util.find_library('opus') or 'libopus.so.0'
              self.lib = ctypes.CDLL(libname)
              self.lib.opus_encoder_create.argtypes = [
                  ctypes.c_int, ctypes.c_int, ctypes.c_int,
                  ctypes.POINTER(ctypes.c_int)
              ]
              self.lib.opus_encoder_create.restype = ctypes.c_void_p
              self.lib.opus_encoder_ctl.restype = ctypes.c_int
              self.lib.opus_encode.argtypes = [
                  ctypes.c_void_p,
                  ctypes.POINTER(ctypes.c_int16),
                  ctypes.c_int,
                  ctypes.POINTER(ctypes.c_ubyte),
                  ctypes.c_int
              ]
              self.lib.opus_encode.restype = ctypes.c_int
              self.lib.opus_encoder_destroy.argtypes = [ctypes.c_void_p]
              err = ctypes.c_int()
              self.enc = self.lib.opus_encoder_create(
                  16000, 1, OPUS_APPLICATION_VOIP, ctypes.byref(err)
              )
              if not self.enc or err.value != 0:
                  raise RuntimeError(
                      'libopus encoder creation failed (error %d)' % err.value
                  )
              for req, val in (
                  (OPUS_SET_BITRATE_REQUEST, 16000),
                  (OPUS_SET_VBR_REQUEST, 0),
                  (OPUS_SET_COMPLEXITY_REQUEST, 10)
              ):
                  rc = self.lib.opus_encoder_ctl(
                      self.enc, ctypes.c_int(req), ctypes.c_int(val)
                  )
                  if rc != 0:
                      raise RuntimeError(
                          'libopus encoder control request %d failed' % req
                      )
              self.frame = 320
              self.packet_bytes = 40
              self.buf = np.empty(0, dtype=np.float32)

          def stop(self):
              if getattr(self, 'enc', None):
                  self.lib.opus_encoder_destroy(self.enc)
                  self.enc = None
              return super().stop()

          def general_work(self, input_items, output_items):
              x = input_items[0]
              if len(x):
                  self.buf = np.concatenate(
                      (self.buf, x.astype(np.float32, copy=False))
                  )
                  self.consume(0, len(x))
              out = output_items[0]
              n = min(len(self.buf) // self.frame,
                      len(out) // self.packet_bytes)
              if n <= 0:
                  return 0
              p = 0
              for i in range(n):
                  pcm = np.clip(
                      self.buf[i*self.frame:(i+1)*self.frame],
                      -1.0, 1.0
                  )
                  pcm16 = (pcm * 32767.0).astype(np.int16)
                  obuf = (ctypes.c_ubyte * 4000)()
                  nb = self.lib.opus_encode(
                      self.enc,
                      pcm16.ctypes.data_as(ctypes.POINTER(ctypes.c_int16)),
                      self.frame,
                      obuf,
                      4000
                  )
                  if nb != self.packet_bytes:
                      raise RuntimeError(
                          'libopus returned %d bytes; expected 40 for 16 kbps CBR/20 ms'
                          % nb
                      )
                  out[p:p+self.packet_bytes] = np.frombuffer(
                      bytes(obuf[:self.packet_bytes]), dtype=np.uint8
                  )
                  p += self.packet_bytes
              self.buf = self.buf[n*self.frame:]
              return p
    comment: 16 kHz mono Opus 16 kbps CBR, 20 ms using system libopus.
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: 200 kHz is Pluto hardware minimum; software channel filter follows.
    filter_source: '''Auto'''
    frequency: rx_freq
    gain1: '''slow_attack'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: pluto_rate
    type: fc32
  states: {state: disabled}
- name: pluto_tx
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq
    samplerate: pluto_rate
    type: fc32
  states: {state: disabled}
- name: power_sink
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_VERT
    label1: TX
    label2: RX
    max: '5'
    min: '-120'
    name: '"Baseband Power"'
    nconnections: '2'
    type: float
    unit1: dBFS
    unit2: dBFS
    update_time: '0.20'
  states: {}
- name: qpsk_mod_tx
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: '0.25'
    samples_per_symbol: '4'
  states: {}
- name: qpsk_symbols_tx
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    comment: Split each packed byte into 2-bit QPSK symbol indices (0..3).
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: runtime_note
  id: note
  parameters: {}
  states: {}
- name: rx_audio_lp
  id: low_pass_filter
  parameters:
    comment: Final 7 kHz speech low-pass after Opus decode.
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_audio
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: rx_audio_time
  id: qtgui_time_sink_x
  parameters:
    color1: red
    entags: 'False'
    grid: 'True'
    label1: RX
    name: '"RX Audio"'
    size: '4000'
    srate: samp_audio
    tr_level: '0'
    type: float
  states: {}
- name: rx_channel
  id: low_pass_filter
  parameters:
    comment: Software channel filter removes out-of-channel noise before synchronization.
    cutoff_freq: '12500'
    decim: '1'
    gain: '1'
    samp_rate: baseband_rate
    type: fir_filter_ccf
    width: '2500'
    win: window.WIN_HAMMING
  states: {}
- name: rx_const_dec
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: rx_const_sink
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    label1: Symbols
    name: '"RX QPSK Constellation"'
    size: '2048'
    tr_level: '0'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rx_costas
  id: digital_costas_loop_cc
  parameters:
    comment: QPSK carrier recovery.
    order: '4'
    w: '0.01'
  states: {}
- name: rx_decim
  id: rational_resampler_xxx
  parameters:
    comment: '20x decimation: Pluto 1.696 MSPS -> 84.8 kS/s modem rate.'
    decim: '20'
    fbw: '0.45'
    interp: '1'
    type: ccc
  states: {}
- name: rx_diff
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: rx_fft
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: baseband_rate
    comment: RX filtered spectrum.
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    label: RX filtered spectrum
    name: RX filtered
    showports: 'True'
    type: complex
  states: {}
- name: rx_fll
  id: digital_fll_band_edge_cc
  parameters:
    comment: Coarse frequency recovery for independent Pluto oscillators.
    filter_size: '65'
    rolloff: '0.25'
    samps_per_sym: sps
    type: cc
    w: '0.02'
  states: {}
- name: rx_mag
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_power_add
  id: blocks_add_const_vxx
  parameters:
    const: '1e-12'
    type: float
  states: {}
- name: rx_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: rx_rrc
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.25'
    comment: Matched RRC filter before symbol timing recovery.
    decim: '1'
    gain: '1'
    ntaps: '161'
    samp_rate: baseband_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: rx_sym
  id: digital_symbol_sync_xx
  parameters:
    constellation: qpsk_const
    damping: '1.0'
    loop_bw: '0.03'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: rx_symbols_to_bits
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    comment: Expand each decoded QPSK symbol index into two MSB-first FEC bits.
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: rx_volume_block
  id: blocks_multiply_const_vxx
  parameters:
    comment: Speaker volume.
    const: rx_volume
    type: float
  states: {}
- name: sim_audio
  id: analog_sig_source_x
  parameters:
    amp: sim_audio_amp
    comment: Deterministic speech-band tone used for a hardware-free end-to-end test.
    freq: sim_audio_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_audio
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: sim_channel
  id: channels_channel_model
  parameters:
    comment: 'Software RF channel model: AWGN + carrier offset.'
    epsilon: '1.0'
    freq_offset: sim_freq_offset
    noise_voltage: sim_noise
    seed: '42'
    taps: '[1.0+0j]'
  states: {}
- name: sim_throttle
  id: blocks_throttle
  parameters:
    comment: Real-time pacing for software-only test.
    samples_per_second: pluto_rate
    type: complex
  states: {}
- name: simulation_note
  id: note
  parameters: {}
  states: {}
- name: tx_audio_time
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    label1: LIVE Mic
    name: '''LIVE Microphone'''
    size: '4000'
    srate: samp_audio
    tr_level: '0'
    type: float
  states: {}
- name: tx_dc
  id: dc_blocker_xx
  parameters:
    comment: Remove microphone DC bias.
    length: '64'
    long_form: 'True'
    type: ff
  states: {}
- name: tx_fft
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: baseband_rate
    comment: TX baseband spectrum.
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    label: TX baseband spectrum
    name: TX baseband
    showports: 'True'
    type: complex
  states: {}
- name: tx_gain
  id: blocks_multiply_const_vxx
  parameters:
    comment: Microphone level trim.
    const: mic_gain
    type: float
  states: {}
- name: tx_hp
  id: high_pass_filter
  parameters:
    comment: Remove subsonic rumble.
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    samp_rate: samp_audio
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: tx_limiter
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Low-latency soft limiter for speech."""
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="speech_soft_limiter",
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              self.drive = 1.8
              self.norm = np.tanh(self.drive)

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              y[:] = np.tanh(self.drive * x) / self.norm
              return len(y)
    comment: Prevents clipping and evens speech level.
  states: {}
- name: tx_lp
  id: low_pass_filter
  parameters:
    comment: 'Speech bandwidth: ~100 Hz to 7 kHz.'
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_audio
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: tx_mag
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: tx_monitor_block
  id: blocks_multiply_const_vxx
  parameters:
    comment: Live microphone sidetone gain; zero means disabled.
    const: tx_monitor_gain
    type: float
  states: {}
- name: tx_power_add
  id: blocks_add_const_vxx
  parameters:
    const: '1e-12'
    type: float
  states: {}
- name: tx_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: tx_ptt_gate
  id: blocks_multiply_const_vxx
  parameters:
    comment: Half-duplex PTT gate. Zero RF waveform when RX / Standby is selected.
    const: ptt_enable
    type: complex
  states: {}
- name: tx_to_pluto
  id: rational_resampler_xxx
  parameters:
    comment: '20x interpolation: 84.8 kS/s -> 1.696 MSPS for Pluto.'
    decim: '1'
    fbw: '0.45'
    interp: '20'
    type: ccc
  states: {}
- name: unpack_bits_tx
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    comment: Pack 8 coded bits into each byte for QPSK symbol mapping.
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}

connections:
- [audio_mix, '0', audio_sink, '0']
- [audio_src, '0', tx_audio_time, '0']
- [audio_src, '0', tx_dc, '0']
- [fec_rx, '0', opus_dec, '0']
- [fec_tx, '0', unpack_bits_tx, '0']
- [opus_dec, '0', rx_audio_lp, '0']
- [opus_enc, '0', fec_tx, '0']
- [qpsk_mod_tx, '0', tx_fft, '0']
- [qpsk_mod_tx, '0', tx_ptt_gate, '0']
- [qpsk_symbols_tx, '0', qpsk_mod_tx, '0']
- [rx_audio_lp, '0', rx_volume_block, '0']
- [rx_channel, '0', rx_fft, '0']
- [rx_channel, '0', rx_fll, '0']
- [rx_channel, '0', rx_mag, '0']
- [rx_const_dec, '0', rx_diff, '0']
- [rx_costas, '0', rx_const_dec, '0']
- [rx_costas, '0', rx_const_sink, '0']
- [rx_decim, '0', rx_channel, '0']
- [rx_diff, '0', rx_symbols_to_bits, '0']
- [rx_fll, '0', rx_rrc, '0']
- [rx_fll, '1', fll_time, '0']
- [rx_mag, '0', rx_power_add, '0']
- [rx_power_add, '0', rx_power_db, '0']
- [rx_power_db, '0', power_sink, '1']
- [rx_rrc, '0', rx_sym, '0']
- [rx_sym, '0', rx_costas, '0']
- [rx_symbols_to_bits, '0', fec_rx, '0']
- [rx_volume_block, '0', audio_mix, '1']
- [rx_volume_block, '0', rx_audio_time, '0']
- [sim_channel, '0', rx_decim, '0']
- [sim_throttle, '0', sim_channel, '0']
- [tx_dc, '0', tx_hp, '0']
- [tx_gain, '0', tx_limiter, '0']
- [tx_hp, '0', tx_lp, '0']
- [tx_limiter, '0', opus_enc, '0']
- [tx_limiter, '0', tx_monitor_block, '0']
- [tx_lp, '0', tx_gain, '0']
- [tx_mag, '0', tx_power_add, '0']
- [tx_monitor_block, '0', audio_mix, '0']
- [tx_power_add, '0', tx_power_db, '0']
- [tx_power_db, '0', power_sink, '0']
- [tx_ptt_gate, '0', tx_mag, '0']
- [tx_ptt_gate, '0', tx_to_pluto, '0']
- [tx_to_pluto, '0', sim_throttle, '0']
- [unpack_bits_tx, '0', qpsk_symbols_tx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
